# Keil uVision project MP2500-1.uvprojx, settings and files
target FreeRTOS_RGB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c include: ..\Core;.\obj;..\user;..\Libraries\STM32F7xx_HAL_Driver\Inc;..\system\delay;..\system\sys;..\system\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\hardware\LED;..\hardware\LCD;..\hardware\KEY;..\hardware\SDRAM;..\hardware\EXTI;..\hardware;..\hardware\ADC;..\hardware\DAC;..\hardware\TIM;..\hardware\I2C;..\hardware\UART;..\hardware\CAN;..\hardware\RTC;..\hardware\SDMMC;..\malloc;..\Fatfs\src;..\Fatfs\exfuns;..\hardware\MPU;..\EMWIN\Demo;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\hardware\TOUCH;..\DSP_LIB\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group User
    ../user/: main.c stm32f7xx_it.c system_stm32f7xx.c
  group System
    ../system/sys/: sys.c
    ../system/usart/: usart.c
    ../system/delay/: delay.c
  group Core
    ../Core/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_can.c stm32f7xx_hal_adc.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_fmc.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_sd.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_dma2d.c
  group Hardware
    ../hardware/: bsp.c
    ../hardware/LED/: bsp_led.c
    ../hardware/KEY/: bsp_key.c
    ../hardware/EXTI/: bsp_exti.c
    ../hardware/LCD/: bsp_lcd.c bsp_ltdc.c
    ../hardware/SDRAM/: bsp_sdram.c
    ../hardware/ADC/: bsp_adc.c
    ../hardware/DAC/: bsp_dac.c
    ../hardware/TIM/: bsp_tim.c
    ../hardware/I2C/: bsp_iic.c
    ../hardware/UART/: bsp_uart.c
    ../hardware/CAN/: bsp_can.c
    ../hardware/RTC/: bsp_rtc.c
    ../hardware/SDMMC/: bsp_sdmmc_sdcard.c
    ../hardware/MPU/: mpu.c
    ../hardware/MAX6675/: bsp_max6675.c
  group Touch
    ../hardware/TOUCH/: bsp_ctiic.c bsp_ft5206.c bsp_gt9147.c bsp_ott2001a.c bsp_touch.c
  group Malloc
    ../malloc/: malloc.c
  group Fatfs
    ../Fatfs/src/: diskio.c ff.c
    ../Fatfs/exfuns/: exfuns.c
    ../Fatfs/src/option/: cc936.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM7lfsp_math.lib
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: GUI_CM4F_L.lib
  group EMWIN_CONFIG
    ../EMWIN/STemWin/Config/: GUIConf.c GUIDRV_Template.c GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c LCDConf_Lin_Template.c
    ../EMWIN/STemWin/OS/: GUI_X_FreeRTOS.c
  group EMWIN_DEMO
    ../EMWIN/Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Touch.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Doc
    ../doc/: readme.txt updata_history.txt c模版.txt h模版.txt
target FreeRTOS_MCU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: as above
  output: LED +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: ..\Core;.\obj;..\user;..\Libraries\STM32F7xx_HAL_Driver\Inc;..\system\delay;..\system\sys;..\system\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\hardware\LED;..\hardware\LCD;..\hardware\KEY;..\hardware\SDRAM;..\hardware\EXTI;..\hardware;..\hardware\ADC;..\hardware\DAC;..\hardware\TIM;..\hardware\I2C;..\hardware\UART;..\hardware\CAN;..\hardware\RTC;..\hardware\SDMMC;..\malloc;..\Fatfs\src;..\Fatfs\exfuns;..\hardware\MPU;..\EMWIN\Demo;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\hardware\TOUCH;..\DSP_LIB\Include;..\hardware\MAX6675
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
